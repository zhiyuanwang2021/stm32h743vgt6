# Keil uVision project stm32h743vgt6.uvprojx, settings and files
target stm32h743vgt6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x807FFFF) IROM2(0x8100000-0x817FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: stm32h743vgt6 +hex
  AfterMake: "$K\ARM\ARMCC\bin\fromelf.exe" --bin --output="$P@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,USE_PWR_LDO_SUPPLY
  c include: ../Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Host;../Hardware;../Ethenet;../Ethenet/W5500;../Ethenet/bsp;../ADRC;../Regression;../PID;../Easylogger/inc;../Hardware/MRAM;../ModbusLib/include;../Drivers/CMSIS/Include
  asm include: ../Inc;../Host;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x8100000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/User/Core
    ../Src/: main.c gpio.c freertos.c i2c.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/Host
    ../Host/: control.c in_out.c posGenerator.c communicate.c communicate.h gParameter.c gParameter.h EthProtocol.c Eeprom_manage.c Eeprom_manage.h userdebug.c sensor.c sensor.h mram_manage.c mram_manage.h
  group Regression
    ../Regression/: lsm.c lsm.h
  group ADRC
    ../ADRC/: td.c td.h adrc.c adrc.h
  group Hardware
    ../Hardware/: DI.c DO.c RS485.c Computer_vision.c CRC16.c Servo_driver.c myFifo.c Encoder.c EEPROM.c filter.c CS5552.c
    ../Hardware/MRAM/: MRAM.c
  group Ethernet
    ../Ethenet/: ETHw5500.c loopback.c socket.c wizchip_conf.c
    ../Ethenet/W5500/: w5500.c
    ../Ethenet/bsp/: bsp_spi.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group PID
    ../PID/: pid.c pid.h
  group Easylogger
    ../Easylogger/port/: elog_port.c
    ../Easylogger/src/: elog.c elog_utils.c elog_async_freertos.c
    ../Easylogger/inc/: elog.h elog_cfg.h
  group ModbusLib
    ../ModbusLib/src/slave/: modbus_slave.c modbus_slave_rtu.c modbus_slave_tcp.c
    ../ModbusLib/src/: modbus_common.c
    ../ModbusLib/include/: modbus_slave.h modbus_common.h
software components: CMSIS:CORE 4.3.0
